<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ebno</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>schsize</value></param>
<param><key>value</key><value>dsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fcch</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nslot</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dsize</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from scipy import sqrt, log10, power</value></param>
</block>
<block>
<key>viterbi_framer_bb</key>
<param><key>id</key><value>viterbi_framer_bb_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcch</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dsize</value></param>
</block>
<block>
<key>viterbi_nrz_encoder</key>
<param><key>id</key><value>viterbi_nrz_encoder_0</value></param>
<param><key>a</key><value>1</value></param>
<param><key>diff</key><value>True</value></param>
</block>
<block>
<key>viterbi_gmskmod_bc</key>
<param><key>id</key><value>viterbi_gmskmod_bc_0</value></param>
<param><key>L</key><value>1</value></param>
<param><key>M</key><value>3</value></param>
<param><key>BT</key><value>0000.3</value></param>
</block>
<block>
<key>viterbi_demod_cf</key>
<param><key>id</key><value>viterbi_demod_cf_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcch</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dsize</value></param>
</block>
<block>
<key>viterbi_nrz_decode_fb</key>
<param><key>id</key><value>viterbi_nrz_decode_fb_0</value></param>
<param><key>set0</key><value>1</value></param>
</block>
<block>
<key>viterbi_awgn_cc</key>
<param><key>id</key><value>viterbi_awgn_cc_0_0</value></param>
<param><key>std</key><value>sqrt(power(10, - (ebno)/10.0))</value></param>
<param><key>seed</key><value>479</value></param>
</block>
<block>
<key>viterbi_channel_dop_cc</key>
<param><key>id</key><value>viterbi_channel_dop_cc_0</value></param>
<param><key>tot_bits</key><value>19200*600</value></param>
</block>
<block>
<key>viterbi_sync_cc</key>
<param><key>id</key><value>viterbi_sync_cc_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcch</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dsize</value></param>
</block>
<block>
<key>viterbi_bercount_b</key>
<param><key>id</key><value>viterbi_bercount_b_0</value></param>
<param><key>file</key><value>/home/sam/Desktop/gr_winter/Testing/short_grc_ber.dat</value></param>
<param><key>append</key><value>True</value></param>
<param><key>ebno</key><value>ebno</value></param>
<param><key>L</key><value>19200*600</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>19200*600</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>viterbi_nrz_encoder_0</source_block_id><sink_block_id>viterbi_gmskmod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_framer_bb_0</source_block_id><sink_block_id>viterbi_nrz_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>viterbi_framer_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_demod_cf_0</source_block_id><sink_block_id>viterbi_nrz_decode_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_gmskmod_bc_0</source_block_id><sink_block_id>viterbi_awgn_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_sync_cc_0</source_block_id><sink_block_id>viterbi_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>viterbi_bercount_b_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>viterbi_nrz_decode_fb_0</source_block_id><sink_block_id>viterbi_bercount_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_awgn_cc_0_0</source_block_id><sink_block_id>viterbi_channel_dop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_channel_dop_cc_0</source_block_id><sink_block_id>viterbi_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
