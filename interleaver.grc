<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ebno</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BT</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ConstK</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_len</value></param>
<param><key>value</key><value>900</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rows</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ds_size</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dssize</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fcchsize</value></param>
<param><key>value</key><value>80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>schsize</value></param>
<param><key>value</key><value>dssize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nslot</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cols</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>g1</value></param>
<param><key>value</key><value>91</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>g2</value></param>
<param><key>value</key><value>113</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>TO_CC_DECODER</value></param>
<param><key>stream_id</key><value>2</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>102400</value></param>
<param><key>bins</key><value>400</value></param>
<param><key>xmin</key><value>-2</value></param>
<param><key>xmax</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>viterbi_nrz_decode_fb</key>
<param><key>id</key><value>viterbi_nrz_decode_fb_0</value></param>
<param><key>set0</key><value>-1</value></param>
</block>
<block>
<key>viterbi_addfirstN_bb</key>
<param><key>id</key><value>viterbi_addfirstN_bb_0</value></param>
<param><key>N</key><value>nslot*(dssize-2)</value></param>
</block>
<block>
<key>viterbi_framer_bb</key>
<param><key>id</key><value>viterbi_framer_bb_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcchsize</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dssize</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>viterbi_awgn_cc</key>
<param><key>id</key><value>viterbi_awgn_cc_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>std</key><value>sqrt(power(10, - (ebno-3)/10.0))</value></param>
<param><key>seed</key><value>479</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>TO_GMSK_MOD</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>viterbi_convdec</key>
<param><key>id</key><value>viterbi_convdec_0</value></param>
<param><key>N</key><value>cc_len-ConstK+1</value></param>
<param><key>M</key><value>ConstK</value></param>
<param><key>G1</key><value>g1</value></param>
<param><key>G2</key><value>g2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from scipy import sqrt, log10, power</value></param>
</block>
<block>
<key>viterbi_interleave_ff</key>
<param><key>id</key><value>viterbi_interleave_ff_0</value></param>
<param><key>r</key><value>rows</value></param>
<param><key>c</key><value>cols</value></param>
</block>
<block>
<key>viterbi_convenc_bf</key>
<param><key>id</key><value>viterbi_convenc_bf_0</value></param>
<param><key>K</key><value>ConstK</value></param>
<param><key>g1</key><value>g1</value></param>
<param><key>g2</key><value>g2</value></param>
</block>
<block>
<key>viterbi_nrz_encoder</key>
<param><key>id</key><value>viterbi_nrz_encoder_0</value></param>
<param><key>a</key><value>1</value></param>
<param><key>diff</key><value>True</value></param>
</block>
<block>
<key>viterbi_gmskmod_bc</key>
<param><key>id</key><value>viterbi_gmskmod_bc_0</value></param>
<param><key>L</key><value>1</value></param>
<param><key>M</key><value>3</value></param>
<param><key>BT</key><value>BT</value></param>
</block>
<block>
<key>viterbi_awgn_cc</key>
<param><key>id</key><value>viterbi_awgn_cc_0</value></param>
<param><key>std</key><value>sqrt(power(10, - (ebno-3)/10.0))</value></param>
<param><key>seed</key><value>47</value></param>
</block>
<block>
<key>viterbi_sync_cc</key>
<param><key>id</key><value>viterbi_sync_cc_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcchsize</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dssize</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>viterbi_demod_cf</key>
<param><key>id</key><value>viterbi_demod_cf_0</value></param>
<param><key>nslot</key><value>nslot</value></param>
<param><key>fcchsize</key><value>fcchsize</value></param>
<param><key>schsize</key><value>schsize</value></param>
<param><key>dssize</key><value>dssize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1</value></param>
</block>
<block>
<key>viterbi_dropfirstN_ff</key>
<param><key>id</key><value>viterbi_dropfirstN_ff_0</value></param>
<param><key>N</key><value>(dssize-2)*nslot</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>2</value></param>
</block>
<block>
<key>viterbi_interleave_ff</key>
<param><key>id</key><value>viterbi_interleave_ff_0_0</value></param>
<param><key>r</key><value>cols</value></param>
<param><key>c</key><value>rows</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/jayram/Desktop/gnuradio/test_files/out.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>cc_len*1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>viterbi_zeropad_bb</key>
<param><key>id</key><value>viterbi_zeropad_bb_0</value></param>
<param><key>L</key><value>cc_len-ConstK+1</value></param>
<param><key>M</key><value>ConstK-1</value></param>
</block>
<block>
<key>viterbi_bercount_b</key>
<param><key>id</key><value>viterbi_bercount_b_0</value></param>
<param><key>file</key><value>/home/jayram/Desktop/ber_k7z.dat</value></param>
<param><key>append</key><value>True</value></param>
<param><key>ebno</key><value>ebno</value></param>
<param><key>L</key><value>20000000</value></param>
</block>
<connection><source_block_id>viterbi_convdec_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_interleave_ff_0_0</source_block_id><sink_block_id>viterbi_convdec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_interleave_ff_0</source_block_id><sink_block_id>TO_GMSK_MOD</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>viterbi_interleave_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_convenc_bf_0</source_block_id><sink_block_id>viterbi_interleave_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_interleave_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>viterbi_awgn_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_awgn_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>viterbi_interleave_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_nrz_encoder_0</source_block_id><sink_block_id>viterbi_gmskmod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>viterbi_nrz_decode_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_gmskmod_bc_0</source_block_id><sink_block_id>viterbi_awgn_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_framer_bb_0</source_block_id><sink_block_id>viterbi_nrz_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_awgn_cc_0</source_block_id><sink_block_id>viterbi_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_sync_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>viterbi_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>TO_CC_DECODER</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_sync_cc_0</source_block_id><sink_block_id>viterbi_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_zeropad_bb_0</source_block_id><sink_block_id>viterbi_convenc_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_convdec_0</source_block_id><sink_block_id>viterbi_bercount_b_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>viterbi_zeropad_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_sync_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_demod_cf_0</source_block_id><sink_block_id>viterbi_dropfirstN_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_dropfirstN_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>viterbi_bercount_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_nrz_decode_fb_0</source_block_id><sink_block_id>viterbi_addfirstN_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>viterbi_addfirstN_bb_0</source_block_id><sink_block_id>viterbi_framer_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
